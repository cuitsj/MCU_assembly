# Keil uVision project six.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: six +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 6-1.asm 6-2.asm 6-3.asm 6-4.asm 6-5.asm 6-6.asm 6-7-1.asm 6-7-2.asm
